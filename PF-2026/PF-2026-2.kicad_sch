File: PF-2026/PF-2026-2.kicad_sch (KiCad schematic)
At the start: 57 parts

Commit message: Finalise PCB design
Connections:
- net IO renamed IO3
